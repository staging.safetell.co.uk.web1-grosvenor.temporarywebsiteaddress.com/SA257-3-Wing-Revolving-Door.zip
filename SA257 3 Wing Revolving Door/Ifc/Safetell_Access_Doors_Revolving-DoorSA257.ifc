Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-10-26T16:20:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190507_1515(x64) - Exporter 17.0.517.0 - Alternate UI 17.15.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 26 16:20:17 2021 * Host: DESKTOP-8K2M230 * Database: C:\Users\DucLN\AppData\Local\Temp\{03E496DD-C458-4E03-880C-3234BC43CB22}\ifc * Database version: 5507 * Database creation date: Tue Oct 26 16:20:15 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 26 16:20:15 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 26 16:20:15 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcCurtainWall: Curtain Wall:Curtain Wall, Curtain Wall:Curtain Wall:321525
In: Level 1
Pset_CurtainWallCommon - Reference: Curtain Wall; IsExternal: yes

# IfcDoor: Revolving Door – 2300 dia x 2325mm tall (4 wing), Revolving Door – 2300 dia x 2325mm tall (4 wing):Revolving Door – 2300 dia x 2325mm tall (4 wing):321533
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Steel, Glass
OverallHeight: 2384.5 mm; OverallWidth: 2303.84 mm
Pset_DoorCommon - Reference: Revolving Door – 2300 dia x 2325mm tall (4 wing); IsExternal: no

# IfcPlate: Glazed (13)
In: Level 1
Type - ElementType: Glazed; PredefinedType: CURTAIN_PANEL; Material: Glass
Pset_PlateCommon - IsExternal: yes; Reference: Glazed; LoadBearing: yes; ThermalTransmittance: 6.7069 kg/K/s3
Name (System Panel:Glazed:...)
321526
321529
321531
321535
321537
321539
321541
321542
321543
321544
321545
321546
321547
